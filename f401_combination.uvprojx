# Keil uVision project f401_combination.uvprojx, settings and files
target f401 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f401_combination +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\Library;.\Start;.\System;.\User;.\ucos2\Config;.\ucos2\Port;.\ucos2\Source;.\Hardware;.\ANO_Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./User/: app.c app.h BSP.c BSP.h main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group Start
    ./Start/: core_cm4.h core_cmFunc.h core_cmInstr.h startup_stm32f401xx.s stm32f4xx.h system_stm32f4xx.h core_cmSimd.h system_stm32f4xx.c
  group System
    ./System/: delay.h delay.c
  group Library
    ./Library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group Hardware
    ./Hardware/: ppm.h ppm.c pwm.h pwm.c gpio.h gpio.c nvic.c nvic.h bluetooth.h buletooth.c MPU6050.c MPU6050.h MPU6050Rag.h MYI2C.c MYI2C.h HMC5883L.c HMC5883L.h USART.c USART.h usart1.c usart1.h attitude_control.c attitude_control.h control_timer.c control_timer.h PID.h PID.c DMA.c DMA.h
  group Source
    ./ucos2/Source/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.c ucos_ii.h
  group Ports
    ./ucos2/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Config
    ./ucos2/Config/: app_cfg.h app_hooks.c os_cfg.h includes.h
  group ANO_Protocol
    ./ANO_Protocol/: ANO_Protocol.c ANO_Protocol.h
